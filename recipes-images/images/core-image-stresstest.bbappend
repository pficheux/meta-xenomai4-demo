IMAGE_INSTALL:append = " \
		     xenomai4-dev \
		     libgpiod-dev \
		     libgpiod-tools \
		     valgrind \
		     "
