# Minimal image for Xenomai 4
include recipes-core/images/core-image-minimal.bb

IMAGE_INSTALL += "rt-tests xenomai4"

