CMDLINE_ISOL_CPUS="isolcpus=3 evl.oobcpus=3"
